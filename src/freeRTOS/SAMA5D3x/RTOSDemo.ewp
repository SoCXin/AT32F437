# IAR project RTOSDemo.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D35 Atmel ATSAMA5D35
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: sama5d3x; sram; TRACE_LEVEL=0
  ICCARM.CCDiagSuppress: Pa131, Pa039
  ICCARM.CCIncludePath2: ..\user\..\user\AtmelFiles\libboard_sama5d3x-ek; ..\user\..\user\AtmelFiles\libchip_sama5d3x; ..\user\..\user\AtmelFiles\libchip_sama5d3x\include; ..\user\; ..\Source\include; ..\Source\portable\IAR\ARM_CA5_No_GIC; ..\Common\include; ..\user\Full_Demo; ..\Source\FreeRTOS-Plus-CLI; ..\user\..\user\AtmelFiles\usb\device; ..\user\..\user\AtmelFiles\usb\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: sama5d3x; sram; __ASSEMBLY__
  AARM.AUserIncludes: .; ..\Source\portable\IAR\ARM_CA5_No_GIC
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: ..\user\AtmelFiles\libboard_sama5d3x-ek\resources\ewarm\sama5d3x\sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group (top)
    ../user/: cstartup_with_FreeRTOS_vectors.s FreeRTOS_tick_config.c FreeRTOSConfig.h LEDs.c main.c
  group Atmel Files/libboard_sama5d3x-ek
    ../user/AtmelFiles/libboard_sama5d3x-ek/source/: board_lowlevel.c board_memories.c dbg_util.c dbgu_console.c led.c
  group Atmel Files/libchip_sama5d3x
    ../user/AtmelFiles/libchip_sama5d3x/source/: aic.c mmu.c pio.c pio_it.c pit.c pmc.c tc.c USBD_HAL.c wdt.c
    ../user/AtmelFiles/libchip_sama5d3x/cp15/: cp15.c cp15_asm_iar.s
  group Atmel Files/usb
    ../user/AtmelFiles/usb/: USBDDriverDescriptors.c
  group Atmel Files/usb/common/cdc
    ../user/AtmelFiles/usb/common/cdc/: CDCLineCoding.c CDCSetControlLineStateRequest.c
  group Atmel Files/usb/common/core
    ../user/AtmelFiles/usb/common/core/: USBDescriptors.c USBRequests.c
  group Atmel Files/usb/device/cdc-serial
    ../user/AtmelFiles/usb/device/cdc-serial/: CDCDSerial.c CDCDSerial_Callbacks.c CDCDSerialDriver.c CDCDSerialPort.c
  group Atmel Files/usb/device/core
    ../user/AtmelFiles/usb/device/core/: USBD.c USBDCallbacks.c USBDDriver.c USBDDriverCallbacks.c
  group Blinky Demo
    ../user/blinky_demo/: main_blinky.c
  group FreeRTOS Source
    ../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS Source/portable
    ../Source/portable/IAR/ARM_CA5_No_GIC/: port.c portASM.h portASM.s portmacro.h
  group FreeRTOS Source/portable/MemMang
    ../Source/portable/MemMang/: heap_4.c
  group FreeRTOS+CLI
    ../Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group Full Demo
    ../user/: CDCCommandConsole.c
    ../user/Full_Demo/: IntQueueTimer.c main_full.c reg_test.S
    ../Common/FreeRTOS_Plus_CLI_Demos/: Sample-CLI-commands.c
  group Full Demo/Common Demo Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c IntQueue.c QueueOverwrite.c recmutex.c semtest.c TimerDemo.c
